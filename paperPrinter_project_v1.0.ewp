# IAR project paperPrinter_project_v1.0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: User_App; STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src; Func_Module; STM8S_EVAL
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: paperPrinter_project_v1.0.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Func_Module
    Func_Module/: delay.c delay.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User_App
    User_App/: main.c main.h stm8s_conf.h stm8s_it.c stm8s_it.h
